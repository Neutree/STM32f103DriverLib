# Keil uVision project demo.uvprojx, settings and files
target demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\..\..\..\lib\onchip\USART;..\..\..\..\lib\onchip\GPIO;..\..\..\..\lib\math;..\..\..\..\lib\onchip\interrupt;.\app;..\..\..\..\lib\offchip\LED;..\..\..\..\lib\offchip\MFRC522;..\..\..\..\lib\onchip\SPI;..\..\..\..\lib\onchip\taskManager
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../../../lib/onchip/interrupt/: Interrupt.cpp
    ../../../../lib/onchip/USART/: USART.cpp
    ../../../../lib/onchip/GPIO/: GPIO.cpp
    ../../../../lib/offchip/LED/: LED.cpp
    ../../../../lib/offchip/MFRC522/: MFRC522.cpp
    ../../../../lib/onchip/SPI/: SPI.cpp
    ../../../../lib/onchip/taskManager/: TaskManager.cpp
  group app
    ./app/: Configuration.h main.cpp UserInterrupt.cpp
software components: CMSIS:CORE 4.3.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
