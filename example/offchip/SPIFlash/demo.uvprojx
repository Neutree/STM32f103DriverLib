# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\lib\offchip\LED;..\..\..\lib\offchip\SPIFlash;..\..\..\lib\onchip\GPIO;..\..\..\lib\onchip\SPI;..\..\..\lib\onchip\taskManager;..\..\..\lib\onchip\USART;..\..\..\lib\math;.\app;..\..\..\lib\onchip\interrupt
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group onchip
    ../../../lib/onchip/GPIO/: GPIO.cpp
    ../../../lib/onchip/SPI/: SPI.cpp
    ../../../lib/onchip/USART/: USART.cpp
    ../../../lib/onchip/taskManager/: TaskManager.cpp
    ../../../lib/onchip/interrupt/: Interrupt.cpp
  group offchip
    ../../../lib/offchip/LED/: LED.cpp
    ../../../lib/offchip/SPIFlash/: SPIFlash.cpp
  group app
    ./app/: Main.cpp Configuration.h UserInterrupt.cpp
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
